
PR_append = "+r1"

# look for files in the layer first
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

