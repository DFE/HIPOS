require hydraip-devimage.inc

PR = "r6"
