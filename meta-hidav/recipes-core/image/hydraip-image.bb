require hydraip-image.inc

PR = "${INC_PR}.1"

export IMAGE_BASENAME = "hydraip-image"

IMAGE_FSTYPES = "tar.bz2 squashfs"
