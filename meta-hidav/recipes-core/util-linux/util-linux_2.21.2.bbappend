
PR_append = "+r1"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://tcsetpgrp_hang_fix.patch \
	   "

