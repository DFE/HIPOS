FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
PR_append = "+r2"
#replaces files/lighttpd.conf automatically
