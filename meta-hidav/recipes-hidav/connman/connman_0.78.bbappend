# do not generate rc-links
PRINC = 2
INITSCRIPT_PARAMS = "remove"
