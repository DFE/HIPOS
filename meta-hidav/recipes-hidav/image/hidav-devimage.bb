require hydraip-devimage.inc

PR = "r5"

export IMAGE_BASENAME = "hydraip-devimage"
