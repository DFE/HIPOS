require test-harness.bb

inherit native

